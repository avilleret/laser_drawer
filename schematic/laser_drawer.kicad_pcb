# Repository avilleret/laser_drawer

File README:

march 2013
Antoine Villeret - EnsadLab

Laser_driver is a drop in replacement for Zeliac Server from Sonatronic.
Contrary to Zeliac server, this Puredata based server :
	- is open source
	- is not dedicated to a given hardware

This works with any sound card supported by puredata (but you should remove the DC offset filter

## KiCad design schematic/laser_drawer.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10: 220p
C11, C12, C13, C14, C15, C16, C17, C18, C19, C20: 100nF
C21, C22: 100µF
JP1, JP2, JP3, JP4, JP5, JP6: (no value)
P1: Xin
P2: Yin
P3: Rin
P4: Gin
P5: Bin
P6: Power
P7: SUB-D25 FC
R1, R2, R3, R4, R5: 649
R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: 10k
R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 100
U1, U2, U3, U4, U5: NE5532
VR1, VR2, VR3, VR4, VR5: 10k
XP1: XP-POWER-IH0509S

Connections:
-VAA: C16.1, C17.1, C18.1, C19.1, C20.1, C22.2, JP3.1, JP3.2, JP4.1, JP4.2, JP5.1, JP5.2, JP6.1, JP6.2, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-), U5.4 (V-), XP1.4
/+Bout: P7.7, R20.2
/+Gout: P7.6, R19.2
/+Rout: P7.5, R18.2
/+Xout: P7.1, R16.2
/+Yout: P7.2, R17.2
/-Bout: P7.20, R25.2
/-Gout: P7.19, R24.2
/-Rout: P7.18, R23.2
/-Xout: P7.14, R21.2
/-Yout: P7.15, R22.2
/Vin: P6.2 (PM), XP1.1
GND: C11.1, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, JP1.1, JP1.2, JP2.1, JP2.2, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.25, U1.3 (+), U1.5 (+), U2.3 (+), U2.5 (+), U3.3 (+), U3.5 (+), U4.3 (+), U4.5 (+), U5.3 (+), U5.5 (+), XP1.2, XP1.5
unnamed: C6.2, R13.2, R18.1, U3.7
unnamed: C5.2, R8.1, R23.1, U3.1, VR3.1
unnamed: C6.1, R8.2, R13.1, U3.6 (-)
unnamed: C7.1, R4.2, U4.2 (-), VR4.2
unnamed: P4.2 (PM), R4.1
unnamed: P3.2 (PM), R3.1
unnamed: C8.2, R14.2, R19.1, U4.7
unnamed: C8.1, R9.2, R14.1, U4.6 (-)
unnamed: C7.2, R9.1, R24.1, U4.1, VR4.1
unnamed: C9.1, R5.2, U5.2 (-), VR5.2
unnamed: P5.2 (PM), R5.1
unnamed: C3.2, R7.1, R22.1, U2.1, VR2.1
unnamed: C3.1, R2.2, U2.2 (-), VR2.2
unnamed: P2.2 (PM), R2.1
unnamed: C4.2, R12.2, R17.1, U2.7
unnamed: C5.1, R3.2, U3.2 (-), VR3.2
unnamed: C4.1, R7.2, R12.1, U2.6 (-)
unnamed: P7.4, P7.17
unnamed: C10.1, R10.2, R15.1, U5.6 (-)
unnamed: C10.2, R15.2, R20.1, U5.7
unnamed: C9.2, R10.1, R25.1, U5.1, VR5.1
unnamed: P1.2 (PM), R1.1
unnamed: C1.2, R6.1, R21.1, U1.1, VR1.1
unnamed: C1.1, R1.2, U1.2 (-), VR1.2
unnamed: C2.1, R6.2, R11.1, U1.6 (-)
unnamed: C2.2, R11.2, R16.1, U1.7
VAA: C11.2, C12.2, C13.2, C14.2, C15.2, C21.1, U1.8 (V+), U2.8 (V+), U3.8 (V+), U4.8 (V+), U5.8 (V+), XP1.6

Notes on the sheet:
Vin = 5V Vout = 9V

Board: 2 copper layers, 136.5 x 76.2 mm, 71 parts (0 on the bottom side), 40 nets.

## Commit log

2013-03-04 initial commit of laser_driver
2013-03-04 ça a l'air de marcher
2013-03-04 first commit of a ilda file reader
2013-03-04 help patch
2013-03-04 ILDA official test patterns
2013-03-04 proof of concept
2013-03-04 TODO : fix file reading
2013-03-05 3D frame decoding
2013-03-05 example to display ILDA file
2013-03-05 change object name
2013-03-05 removed old files
2013-03-05 start an ilda server... improve help patch
2013-03-06 working server
2013-03-11 add makeildaframe.c
2013-03-11 help file
2013-03-11 update patches
2013-03-11 c'est le bordel...
2013-03-11 renamed verison
2013-03-11 OSC version, based on liblo
2013-03-11 header
2013-03-12 ildasend : - add disconnect method
    ildareceive :
    - handles blob BUT only for 64-bit system on both sides
2013-03-13 lots of changes : - send all tables in one message of several blobs - add perspective correction on server side (need to be tested) - update Makefile to define HAVE_OPENCV - add severals methods to h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
2013-03-13 ooops forgot that...
2013-03-13 updated help patches
2013-03-13 perspective transformation uses cvMat --> doesn't work
2013-03-14 fix perspective correction
2013-03-14 - fix crash when port already in use - add "connected" message to prepend connection status...
2013-03-14 some patches examples ...
2013-03-14 fix dst_point delete unused method
2013-03-15 add keyword "connected" before connection status fix all compilation warnings add check after each send command and send out error number and string
2013-03-15 fix all build warnings fix a crash when compiling without OpenCV
2013-03-15 improved help files
2013-03-15 examples patches
2013-03-15 fix sending some parameters
2013-03-15 fix sending parameters
2013-03-15 fix receiving some parameters...
2013-03-15 don't resize table, does it fix click ?
2013-03-15 hear clic when blob are received TODO : try to put liblo out of the code = rewrite most of it... (on server side at least)
2013-03-21 pd version without any custom external
2013-03-21 ilda_server a tester
2013-03-21 RPi binaries
2013-03-21 startup script updated server receive_blob patch
2013-03-21 fix crash in perspective correction
2013-03-21 client OK
2013-03-22 je sais plus ce qui a changé...
2013-03-22 mise à jour du script
2013-04-03 fix crash when receiving the first blob
2013-04-03 redraw on perspective correction
2013-04-03 send only table in use
2013-04-16 ildafile : - add color support (standard color table in ilda.h) - fix crash when frame is longer than array - add intensity channel
2013-04-17 - Makefile includes examples - Readme update
2013-04-17 - fix some crash - add autoresize message callback - fix error in resize
2013-04-17 add autoresize message
2013-04-17 example file
2013-04-17 cleanup code
2013-06-18 rebuilt repository tree
2013-06-18 add documentation add schematics
2013-06-20 update doc
2014-02-22 update schematics
2014-02-22 update pdf
